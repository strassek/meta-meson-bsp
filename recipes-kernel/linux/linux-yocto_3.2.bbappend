FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-3.2:"

SRC_URI += "file://rt2x00pci.cfg"
